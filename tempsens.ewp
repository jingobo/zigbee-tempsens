# IAR project tempsens.ewp, settings and files
configuration debug (8051, debug)
  General.OGChipSelectMenu: CC2530F256 CC2530F256
  ICC8051.CCDefines: POWER_SAVING; MTO_RREQ_LIMIT_TIME=4000; BDB_REPORTING; SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; NWK_AUTO_POLL; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_SCENES; ZCL_GROUPS
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: source; source\config; source\zstack\source\hal\include; source\zstack\source\hal\target\CC2530EB; source\zstack\source\mac\include; source\zstack\source\mac\high_level; source\zstack\source\mac\low_level\srf04; source\zstack\source\mac\low_level\srf04\single_chip; source\zstack\source\osal\include; source\zstack\source\services\saddr; source\zstack\source\services\sdata; source\zstack\source\stack\af; source\zstack\source\stack\bdb; source\zstack\source\stack\gp; source\zstack\source\stack\nwk; source\zstack\source\stack\sapi; source\zstack\source\stack\sec; source\zstack\source\stack\sys; source\zstack\source\stack\zcl; source\zstack\source\stack\zdo; source\zstack\source\zmac; source\zstack\source\zmac\f8w
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: linker\cc2530f256.xcl
  group (top)
    source/: main.c mcu.c startup.s51 tasks.c temp.c uart.c zed.c zed_info.c
  group config
    linker/: cc2530f256.xcl
  group config/hal
    source/config/: hal_board_cfg.h hal_mac_cfg.h
  group config/zstack
    source/config/: common.cfg device.cfg zcl.cfg
  group zstack/core
    source/zstack/source/stack/af/: AF.c
  group zstack/core/bdb
    source/zstack/source/stack/bdb/: bdb.c bdb_FindingAndBinding.c bdb_Reporting.c
  group zstack/core/nwk
    source/zstack/source/stack/nwk/: BindingTable.c nwk_globals.c stub_aps.c
  group zstack/core/sys
    source/zstack/source/services/saddr/: saddr.c
    source/zstack/source/stack/sys/: ZDiags.c ZGlobals.c
  group zstack/core/zcl
    source/zstack/source/stack/zcl/: zcl.c zcl_general.c
  group zstack/core/zdo
    source/zstack/source/stack/zdo/: ZDApp.c ZDConfig.c ZDNwkMgr.c ZDObject.c ZDProfile.c ZDSecMgr.c
  group zstack/hal
    source/zstack/source/hal/common/: hal_assert.c hal_drivers.c
  group zstack/hal/cc2530
    source/zstack/source/hal/target/CC2530EB/: hal_adc.c hal_dma.c hal_flash.c hal_key.c hal_led.c hal_sleep.c hal_uart.c
  group zstack/mac/high
    source/zstack/source/mac/high_level/: mac_cfg.c mac_pib.c
  group zstack/mac/low/common
    source/zstack/source/mac/low_level/srf04/: mac_autopend.c mac_backoff_timer.c mac_low_level.c mac_radio.c mac_rx.c mac_rx_onoff.c mac_sleep.c mac_tx.c
  group zstack/mac/low/system
    source/zstack/source/mac/low_level/srf04/single_chip/: mac_csp_tx.c mac_mcu.c mac_mem.c mac_radio_defs.c mac_rffrontend.c
  group zstack/osal
    source/zstack/source/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
  group zstack/osal/cc2530
    source/zstack/source/osal/mcu/cc2530/: OSAL_Math.s51 OSAL_Nv.c
  group zstack/zmac
    source/zstack/source/zmac/f8w/: zmac.c zmac_cb.c
